# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  AfterMake: "D:\Project Folder\STM32\Keil\STM32F103C8T6\SVCS\git.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\STM32F103C8T6
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:GPIO 1.3, Device:Startup 1.0.0
